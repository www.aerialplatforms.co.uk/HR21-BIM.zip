Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2018-10-02T10:34:43
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20171027_0315(x64) - Exporter 17.4.0.0 - Alternate UI 17.4.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013* Module: EDMstepFileFactory/EDMstandAlone* Creation date: Tue Oct 02 10:34:43 2018* Host: NCL-PI04* Database: C:\Users\BocianP\AppData\Local\Temp\{46E7B064-F443-4E4A-9459-B6BAA91CCD21}\ifc* Database version: 5507* Database creation date: Tue Oct 02 10:34:40 2018* Schema: IFC2X3* Model: DataRepository.ifc* Model creation date: Tue Oct 02 10:34:40 2018* Header model: DataRepository.ifc_HeaderModel* Header model creation date: Tue Oct 02 10:34:40 2018* EDMuser: sdai-user* EDMgroup: sdai-group* License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm

# IfcBuildingElementProxy: HR21-4x4, NBS_NiftyliftLtd_SlfPrplldPltfrms_HR21-4x4:HR21-4x4:9805
In: Level 1
Type - Classification: TE_30_30_60_50 (Uniclass2015); Material: NBS_Concept
Type - BOS_General - Author: NBS; BIMObjectName: NBS_NiftyliftLtd_SelfPropelledPlatforms_HR21-4x4; ManufacturerName: Niftylift Ltd; ManufacturerURL: http://www.niftylift.com/uk; NBSCertification: www.nationalbimlibrary.com/cert/1vywnijp; NBSDescription: n/a; NBSReference: n/a; ProductInformation: http://www.niftylift.com/uk/products/cherry-picker/self-propelled/hr21-4x4#specifications; Revision: n/a; Uniclass2015Title: Self propelled platforms; Uniclass2015Code: TE_30_30_60_50; Uniclass2015Version: Tools and Equipment v1.5; Version: 1
Type - NBS_Data - WorkingOutreach: 13000 mm; PlatformHeight: 18800 mm; CageSize: 1800 x 800 mm; PowerOptions: Diesel, hybrid; MinWeight: 6640 kg; SafeWorkingLoad: 250 kg; Gradeability: 45% (24°); TurningRadius: 3890 mm; TravelSpeed: 6 km/h; FlyBoomArc: 150°; CageRotation: 160°
Type - Pset_BuildingElementProxyCommon - FireRating: n/a; IsExternal: yes; LoadBearing: yes; Reference: n/a; Status: New; ThermalTransmittance: 0
Type - IFC - IfcExportAs: IfcBuildingElementProxyType
Type - COBie - AccessibilityPerformance: n/a; AssetType: Movable; Category: TE_30_30_60_50:Self propelled platforms; CodePerformance: n/a; Color: Green, white; Constituents: n/a; Description: Self-propelled heightrider that can lift two people with their tools while delivering, a smoothmeasured operation due to the proportional controls; DurationUnit: year; ExpectedLife: n/a; Features: Toughcage with SiOPS, good manoeuvrability, swing-out engine tray, , suspension system, platform rotation and fly-boom; Finish: n/a; Grade: n/a; Manufacturer: marketing@niftylift.com; Material: Steel; ModelNumber: HR21 4x4; ModelReference: HR21 4x4; Name: SelfPropelledPlatforms_HR21-4x4_NiftyliftLtd; NominalHeight: 15500 mm; NominalLength: 6400 mm; NominalWidth: 1500 mm; ReplacementCost: n/a; Shape: n/a; Size: 20800 x 6620 x 2270 mm; SustainabilityPerformance: n/a; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
COBie - AssetIdentifier: n/a; BarCode: n/a; InstallationDate: 1900-12-31T23:59:59; SerialNumber: n/a; TagNumber: n/a; WarrantyStartDate: 1900-12-31T23:59:59

# IfcBuildingElementProxy: HR21-4x4 (2)
In: Level 1
Type - Classification: TE_30_30_60_50 (Uniclass2015); Material: NBS_Concept
Type - BOS_General - Author: NBS; BIMObjectName: NBS_NiftyliftLtd_SelfPropelledPlatforms_HR21-4x4; ManufacturerName: Niftylift Ltd; ManufacturerURL: http://www.niftylift.com/uk; NBSCertification: www.nationalbimlibrary.com/cert/1vywnijp; NBSDescription: n/a; NBSReference: n/a; ProductInformation: http://www.niftylift.com/uk/products/cherry-picker/self-propelled/hr21-4x4#specifications; Revision: n/a; Uniclass2015Title: Self propelled platforms; Uniclass2015Code: TE_30_30_60_50; Uniclass2015Version: Tools and Equipment v1.5; Version: 1
Type - NBS_Data - WorkingOutreach: 13000 mm; PlatformHeight: 18800 mm; CageSize: 1800 x 800 mm; PowerOptions: Diesel, hybrid; MinWeight: 6640 kg; SafeWorkingLoad: 250 kg; Gradeability: 45% (24°); TurningRadius: 3890 mm; TravelSpeed: 6 km/h; FlyBoomArc: 150°; CageRotation: 160°
Type - Pset_BuildingElementProxyCommon - IsExternal: yes; LoadBearing: yes; ThermalTransmittance: 0; FireRating: n/a; Reference: n/a; Status: New
Type - IFC - IfcExportAs: IfcBuildingElementProxyType
Type - COBie - AccessibilityPerformance: n/a; AssetType: Movable; Category: TE_30_30_60_50:Self propelled platforms; CodePerformance: n/a; Color: Green, white; Constituents: n/a; Description: Self-propelled heightrider that can lift two people with their tools while delivering, a smoothmeasured operation due to the proportional controls; DurationUnit: year; ExpectedLife: n/a; Features: Toughcage with SiOPS, good manoeuvrability, swing-out engine tray, , suspension system, platform rotation and fly-boom; Finish: n/a; Grade: n/a; Manufacturer: marketing@niftylift.com; Material: Steel; ModelNumber: HR21 4x4; ModelReference: HR21 4x4; Name: SelfPropelledPlatforms_HR21-4x4_NiftyliftLtd; NominalHeight: 15500 mm; NominalLength: 6400 mm; NominalWidth: 1500 mm; ReplacementCost: n/a; Shape: n/a; Size: 20800 x 6620 x 2270 mm; SustainabilityPerformance: n/a; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
COBie - AssetIdentifier: n/a; BarCode: n/a; InstallationDate: 1900-12-31T23:59:59; SerialNumber: n/a; TagNumber: n/a; WarrantyStartDate: 1900-12-31T23:59:59
Name (NBS_NiftyliftLtd_SlfPrplldPltfrms_HR21-4x4:HR21-4x4:...)
58611
58617
